# Keil uVision project LCD Interfacing (using my library functions).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LCD Interfacing (using my library functions) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD.h LCD Interfacing (using my library functions).c
